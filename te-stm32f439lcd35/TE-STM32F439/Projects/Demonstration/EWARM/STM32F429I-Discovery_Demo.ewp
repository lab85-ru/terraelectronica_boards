# IAR project STM32F429I-Discovery_Demo.ewp, settings and files
configuration STM32F429I-Discovery_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F439ZI ST STM32F439ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429_439xx; USE_STM32F429I_DISCO; USE_EMBEDDED_PHY
  ICCARM.CCDiagSuppress: Pe111, Pa082
  ICCARM.CCIncludePath2: ..\Config; ..\Core\Devices\STM32F4xx; ..\Core\User; ..\Core\Demo; ..\Core\Lib; ..\Core\Test_Program; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\MSC\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\HID\inc; ..\..\..\Libraries\STM32_USB_Device_Library\Class\Audio\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Utilities; ..\..\..\Utilities\Common; ..\..\..\Utilities\STM32F429i-Discovery; ..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\Utilities\Third_Party\FreeRTOS\Source\include; ..\..\..\Libraries\STemWinLibrary522_4x9i\inc; ..\..\..\Libraries\STemWinLibrary522_4x9i\Config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: te_stm32f439lcd35_demo.hex
  ILINK.IlinkOutputFile: STM32F429I-Discovery_Demo.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appli/Demo
    ../Core/Demo/Res/: common_res.c
    ../Core/Demo/: demo_clock.c demo_cpu.c demo_game.c demo_menu.c demo_microSD.c demo_startup.c demo_systeminfo.c
  group Appli/User
    ../Core/User/: bsp.c fatfs_drv.c fatfs_storage.c main.c rtc.c stm32xxx_it.c
    ./: startup_stm32f429_439xx.s
    ../Core/Devices/STM32F4xx/: system_stm32f4xx.c
  group Appli/Utils
    ../Core/Lib/: cpu_utils.c file_utils.c str_utils.c time_utils.c
  group Libraries/STemWinLibrary522_4x9i/Config
    ../../../Libraries/STemWinLibrary522_4x9i/Config/: GUIConf.c GUIDRV_stm32f429i_discovery.c
  group Libraries/STemWinLibrary522_4x9i/Lib
    ../../../Libraries/STemWinLibrary522_4x9i/Lib/: STemWin522_4x9i_CM4_OS_IAR.a
  group Libraries/STemWinLibrary522_4x9i/OS
    ../../../Libraries/STemWinLibrary522_4x9i/OS/: GUI_X_FreeRTOS.c
  group Libraries/STM32429I-DISCO
    ../../../Utilities/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_ioe.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f4x9_sdio_sd.c
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Utilities/FAT_FS
    ../../../Utilities/Third_Party/fat_fs/src/: ff.c
    ../../../Utilities/Third_Party/fat_fs/src/option/: syscall.c
  group Utilities/FreeRTOS/Core
    ../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Utilities/FreeRTOS/Memory
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Utilities/FreeRTOS/Portable/STM32F1xx
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port_cm3.c portasm_cm3.s
  group Utilities/FreeRTOS/Portable/STM32F4xx
    ../../../Utilities/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port_cm4.c portasm_cm4.s
