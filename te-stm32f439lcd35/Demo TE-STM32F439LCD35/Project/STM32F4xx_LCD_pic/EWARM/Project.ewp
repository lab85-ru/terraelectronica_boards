# IAR project Project.ewp, settings and files
configuration STM324x9I_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F439ZI ST STM32F439ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429X; USE_STM324x9I_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL; ..\..\..\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM324x7I_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F437II ST STM32F437II
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F427X; USE_STM324x7I_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL
  ICCARM.CCOptLevel: 3
configuration STM324xG_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../: system_stm32f4xx.c
  group Doc
    ./: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s startup_stm32f427x.s startup_stm32f429x.s
  group STM32_EVAL/STM324x7I_EVAL
    ../../../Utilities/STM32_EVAL/STM324x7I_EVAL/: stm324x7i_eval.c stm324x7i_eval_fsmc_sram.c stm324x7i_eval_ioe.c stm324x7i_eval_lcd.c
  group STM32_EVAL/STM324x9I_EVAL
    ../../../Utilities/STM32_EVAL/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_fmc_sdram.c stm324x9i_eval_lcd.c
  group STM32_EVAL/STM324xG_EVAL
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_fsmc_sram.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../: fatfs_drv.c fatfs_storage.c main.c stm32f4xx_it.c
    ../../../Utilities/Third_Party/fat_fs/src/: ff.c
    ../../../Utilities/STM32_EVAL/STM324x9I_EVAL/: stm324x9i_eval_ioe16.c stm324x9i_eval_sdio_sd.c
