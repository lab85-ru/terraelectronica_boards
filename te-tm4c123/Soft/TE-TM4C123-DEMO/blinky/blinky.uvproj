# Keil uVision project blinky.uvproj, settings and files
target blinky (ARM-ADS)
  device: TM4C123GE6PZ Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: blinky +hex
  AfterMake: fromelf --bin --output .\rvmdk\blinky.bin .\rvmdk\blinky.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PZ
  c misc: --c99
  c include: ..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: blinky.sct
  link misc: --entry Reset_Handler
  group Source
    ./: blinky.c startup_rvmdk.S
  group Documentation
    ./: readme.txt
