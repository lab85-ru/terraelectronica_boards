# IAR project sd_card.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GE6PZ TexasInstruments TM4C123GE6PZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RA1; ENABLE_LFN
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\third_party
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..; ..\..\..\..\third_party
  OBJCOPY.OOCOutputFile: sd_card.bin
  ILINK.IlinkOutputFile: sd_card.out
  ILINK.IlinkIcfFile: sd_card.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../driverlib/ewarm/Exe/: driverlib.a
    ../grlib/ewarm/Exe/: grlib.a
  group Source
    ../third_party/fatfs/src/option/: cc932.c
    ../utils/: cmdline.c uartstdio.c
    ../third_party/fatfs/src/: ff.c
    ../third_party/fatfs/port/: mmc-ek-lm4f232h5qd.c
    ../drivers/: nokia128x160.c
    ./: sd_card.c startup_ewarm.c
