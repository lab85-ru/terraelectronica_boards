# Keil uVision project sd_card.uvproj, settings and files
target sd_card (ARM-ADS)
  device: TM4C123GE6PZ Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: sd_card +hex
  AfterMake: fromelf --bin --output .\rvmdk\sd_card.bin .\rvmdk\sd_card.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PZ TARGET_IS_BLIZZARD_RA1 ENABLE_LFN
  c misc: --c99
  c include: ..;..\..;..\third_party
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: sd_card.sct
  link misc: --entry Reset_Handler
  group Source
    ../third_party/fatfs/src/option/: cc932.c
    ../utils/: cmdline.c uartstdio.c
    ../third_party/fatfs/src/: ff.c
    ../third_party/fatfs/port/: mmc-ek-lm4f232h5qd.c
    ./: sd_card.c startup_rvmdk.S
    ../drivers/: nokia128x160.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
    ../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
