<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc_pe7\adc_pe7.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\blinky\blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\driverlib\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\grlib\grlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\motion_sensor\motion_sensor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd_card\sd_card.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sine_demo\sine_demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_msc\usb_host_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_keyboard\usb_host_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\usb_host_mouse\usb_host_mouse.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bitband</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo1</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo2</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_serial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_usb</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>can</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hibernate</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>interrupts</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mpu_fault</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs-logger</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sd_card</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sine_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>softuart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>udma_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_bulk</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_serial</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_audio</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_update</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


