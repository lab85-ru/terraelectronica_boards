# Keil uVision project usb_host_msc.uvproj, settings and files
target usb_host_msc (ARM-ADS)
  device: TM4C123GE6PZ Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: usb_host_msc
  AfterMake: fromelf --bin --output .\rvmdk\usb_host_msc.bin .\rvmdk\usb_host_msc.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PZ TARGET_IS_BLIZZARD_RA1
  c misc: --c99
  c include: ..;..\;..\third_party
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: usb_host_msc.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c slidemenuwidget.c nokia128x160.c
    ../third_party/fatfs/port/: fat_usbmsc.c
    ../third_party/fatfs/src/: ff.c
    ./: startup_rvmdk.S usb_host_msc.c
    ../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
    ../grlib/rvmdk/: grlib.lib
    ../usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
