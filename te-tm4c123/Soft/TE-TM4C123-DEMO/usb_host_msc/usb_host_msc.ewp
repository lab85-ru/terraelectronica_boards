# IAR project usb_host_msc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GE6PZ TexasInstruments TM4C123GE6PZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\third_party
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..; ..\..\..\..\third_party
  OBJCOPY.OOCOutputFile: usb_host_msc.bin
  ILINK.IlinkOutputFile: usb_host_msc.out
  ILINK.IlinkIcfFile: usb_host_msc.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../driverlib/ewarm/Exe/: driverlib.a
    ../grlib/ewarm/Exe/: grlib.a
    ../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: buttons.c nokia128x160.c slidemenuwidget.c
    ../third_party/fatfs/port/: fat_usbmsc.c
    ../third_party/fatfs/src/: ff.c
    ./: startup_ewarm.c usb_host_msc.c
    ../utils/: uartstdio.c ustdlib.c
