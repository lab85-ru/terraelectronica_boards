# IAR project sine_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PZ TexasInstruments TM4C123GH6PZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PZ; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: sine_demo.bin
  ILINK.IlinkOutputFile: sine_demo.out
  ILINK.IlinkIcfFile: sine_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../grlib/ewarm/Exe/: grlib.a
    ../usblib/ewarm/Exe/: usblib.a
  group Source
    ../drivers/: nokia128x160.c stripchartwidget.c
    ./: sine_demo.c startup_ewarm.c
