# Keil uVision project sine_demo.uvproj, settings and files
target sine_demo (ARM-ADS)
  device: TM4C123GE6PZ Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: sine_demo +hex
  AfterMake: fromelf --bin --output .\rvmdk\sine_demo.bin .\rvmdk\sine_demo.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PZ TARGET_IS_BLIZZARD_RA1
  c misc: --c99
  c include: ..;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: sine_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ./: sine_demo.c startup_rvmdk.S
    ../drivers/: stripchartwidget.c nokia128x160.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
    ../grlib/rvmdk/: grlib.lib
  group Documentation
    ./: readme.txt
