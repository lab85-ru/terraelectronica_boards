# Keil uVision project motion_sensor.uvproj, settings and files
target motion_sensor (ARM-ADS)
  device: TM4C123GE6PZ Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: motion_sensor +hex
  AfterMake: fromelf --bin --output .\rvmdk\motion_sensor.bin .\rvmdk\motion_sensor.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PZ TARGET_IS_BLIZZARD_RA1
  c misc: --c99
  c include: ..;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\motion_sensor.sct
  link misc: --entry Reset_Handler
  group Source
    ./: motion_sensor.c startup_rvmdk.S
    ../drivers/: stripchartwidget.c LIS302DL.c nokia128x160.c
    ../utils/: ustdlib.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
    ../grlib/rvmdk/: grlib.lib
