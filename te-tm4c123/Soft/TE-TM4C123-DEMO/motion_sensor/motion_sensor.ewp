# IAR project motion_sensor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PZ TexasInstruments TM4C123GH6PZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PZ; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: motion_sensor.bin
  ILINK.IlinkOutputFile: motion_sensor.out
  ILINK.IlinkIcfFile: motion_sensor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../driverlib/ewarm/Exe/: driverlib.a
    ../grlib/ewarm/Exe/: grlib.a
  group Source
    ../drivers/: LIS302DL.c nokia128x160.c stripchartwidget.c
    ./: motion_sensor.c startup_ewarm.c
    ../utils/: ustdlib.c
