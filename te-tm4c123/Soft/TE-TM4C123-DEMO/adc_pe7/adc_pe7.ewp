# IAR project adc_pe7.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GE6PZ TexasInstruments TM4C123GE6PZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PZ; TARGET_IS_BLIZZARD_RA1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: adc_pe7.bin
  ILINK.IlinkOutputFile: adc_pe7.out
  ILINK.IlinkIcfFile: adc_pe7.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../driverlib/ewarm/Exe/: driverlib.a
    ../grlib/ewarm/Exe/: grlib.a
  group Source
    ./: adc_pe7.c startup_ewarm.c
    ../drivers/: nokia128x160.c slidemenuwidget.c
    ../utils/: uartstdio.c ustdlib.c
