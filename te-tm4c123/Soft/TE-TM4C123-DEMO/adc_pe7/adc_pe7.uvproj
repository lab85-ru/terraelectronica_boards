# Keil uVision project adc_pe7.uvproj, settings and files
target adc_pe7 (ARM-ADS)
  device: TM4C123GE6PZ Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: adc_pe7 +hex
  AfterMake: fromelf --bin --output .\rvmdk\adc_pe7.bin .\rvmdk\adc_pe7.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PZ TARGET_IS_BLIZZARD_RA1
  c misc: --c99
  c include: ..;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\adc_pe7.sct
  link misc: --entry Reset_Handler
  group Source
    ./: startup_rvmdk.S adc_pe7.c
    ../utils/: uartstdio.c ustdlib.c
    ../drivers/: nokia128x160.c
  group Documentation
    ./: readme.txt
  group Library
    ../driverlib/rvmdk/: driverlib.lib
    ../grlib/rvmdk/: grlib.lib
