# IAR project TE-IR520 STM32F103RETVirtualCom-CDC_P100.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EMB_FLASH
  ICCARM.CCIncludePath2: ; app\; board\; modules\; library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TE-IR520 STM32F103RETVirtualCom-CDC_P100.hex
  ILINK.IlinkOutputFile: TE-IR520 STM32F103RETVirtualCom-CDC_P100.out
  ILINK.IlinkIcfFile: D:\Soft_TE\Disk_TE-STM32F103\Demo program\TE-IR520 STM32F103RETVirtualCom-CDC_P100\config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    app/: main.c
  group Other
    VirCOM_Driver_XP/: iarvircomport.inf
    ./: readme.txt
    config/: STM32F10x_FLASH.icf
  group STM32F10xFWLib
    library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_tim1.c stm32f10x_usart.c
  group UARTs
    app/: uart.c uart.h
  group USB/Class
    app/: cd_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
  group Vectors
    app/: stm32f10x_it.c stm32f10x_vector.c
