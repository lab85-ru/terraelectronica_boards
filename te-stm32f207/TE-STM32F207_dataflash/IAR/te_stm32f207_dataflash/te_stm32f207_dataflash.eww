<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\te_stm32f207_dataflash.ewp</path>
  </project>
  <batchBuild/>
</workspace>


