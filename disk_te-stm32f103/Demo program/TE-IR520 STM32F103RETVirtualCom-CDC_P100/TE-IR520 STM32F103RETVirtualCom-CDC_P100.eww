<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TE-IR520 STM32F103RETVirtualCom-CDC_P100.ewp</path>
  </project>
  <batchBuild/>
</workspace>


